# Keil uVision project sai.uvprojx, settings and files
target sai flexspi_nor_debug (6100001::V6.10.1::.\ARMCLANG)
  device: MIMXRT1021DAG5A NXP
  pack: NXP.MIMXRT1021_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: sai.out +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, ARM_MATH_CM7, ARM_MATH_CM4, CPU_MIMXRT1021DAG5A, PRINTF_FLOAT_ENABLE=1, MCUXPRESSO_SDK, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_WM8960_ENABLE, DISABLEFLOAT16, SD_ENABLED,TF_LITE_STATIC_MEMORY
  c include: board;source;CMSIS;CMSIS/DSP/Include;CMSIS/DSP/PrivateInclude;CMSIS/DSP/Source/DistanceFunctions;codec;codec/port;codec/port/wm8960;component/gpio;component/i2c;component/lists;component/osa;component/uart;device;drivers;evkmimxrt1020/demo_apps/sai;fatfs/source;fatfs/source/fsl_sd_disk;sdmmc/host;sdmmc/inc;sdmmc/osa;sdmmc/template/usdhc;utilities;xip;./packs/flatbuffers/1.12.0/src/include;./packs/gemmlowp/1.0.0/src;./packs/kissfft/1.3.1/src;./packs/ruy/1.0.0/src;./packs/tensorflow-lite/2.4.0;./packs/tensorflow-lite/2.4.0/tensorflow/lite/;./packs/tensorflow-lite/2.4.0/tensorflow/lite/c;./packs/tensorflow-lite/2.4.0/tensorflow/lite/core/api;./packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels;./packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels/internal;./packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels/internal/optimized;./packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels/internal/reference;./packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels/internal/reference/integer_ops;./packs/tensorflow-lite/2.4.0/tensorflow/lite/micro;./packs/tensorflow-lite/2.4.0/tensorflow/lite/micro/benchmarks;./packs/tensorflow-lite/2.4.0/tensorflow/lite/micro/kernels;./packs/tensorflow-lite/2.4.0/tensorflow/lite/micro/memory_planner;./packs/tensorflow-lite/2.4.0/tensorflow/lite/micro/testing;./packs/tensorflow-lite/2.4.0/tensorflow/lite/schema;./src;./src/i.MXRT
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1021/arm/MIMXRT1021xxxxx_flexspi_nor.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314 --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
--remove
  group board
    board/: board.c board.h clock_config.c clock_config.h dcd.c dcd.h pin_mux.c pin_mux.h sdmmc_config.c sdmmc_config.h
  group CMSIS
    CMSIS/: cachel1_armv7.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm7.h mpu_armv7.h
  group CMSIS/DSP/Include
    CMSIS/DSP/Include/: arm_common_tables.h arm_common_tables_f16.h arm_const_structs.h arm_const_structs_f16.h arm_helium_utils.h arm_math.h arm_math_f16.h arm_math_memory.h arm_math_types.h arm_math_types_f16.h arm_mve_tables.h arm_mve_tables_f16.h arm_vec_math.h arm_vec_math_f16.h
  group CMSIS/DSP/Include/dsp
    CMSIS/DSP/Include/dsp/: basic_math_functions.h basic_math_functions_f16.h bayes_functions.h bayes_functions_f16.h complex_math_functions.h complex_math_functions_f16.h controller_functions.h controller_functions_f16.h debug.h distance_functions.h distance_functions_f16.h fast_math_functions.h fast_math_functions_f16.h filtering_functions.h filtering_functions_f16.h interpolation_functions.h interpolation_functions_f16.h matrix_functions.h matrix_functions_f16.h matrix_utils.h none.h quaternion_math_functions.h statistics_functions.h statistics_functions_f16.h support_functions.h support_functions_f16.h svm_defines.h svm_functions.h svm_functions_f16.h transform_functions.h transform_functions_f16.h utils.h window_functions.h
  group CMSIS/DSP/PrivateInclude
    CMSIS/DSP/PrivateInclude/: arm_sorting.h arm_vec_fft.h arm_vec_filtering.h
  group CMSIS/DSP/Source/BasicMathFunctions
    CMSIS/DSP/Source/BasicMathFunctions/: arm_abs_f16.c arm_abs_f32.c arm_abs_f64.c arm_abs_q15.c arm_abs_q31.c arm_abs_q7.c arm_add_f16.c arm_add_f32.c arm_add_f64.c arm_add_q15.c arm_add_q31.c arm_add_q7.c arm_and_u16.c arm_and_u32.c arm_and_u8.c arm_clip_f16.c arm_clip_f32.c arm_clip_q15.c arm_clip_q31.c arm_clip_q7.c arm_dot_prod_f16.c arm_dot_prod_f32.c arm_dot_prod_f64.c arm_dot_prod_q15.c arm_dot_prod_q31.c arm_dot_prod_q7.c arm_mult_f16.c arm_mult_f32.c arm_mult_f64.c arm_mult_q15.c arm_mult_q31.c arm_mult_q7.c arm_negate_f16.c arm_negate_f32.c arm_negate_f64.c arm_negate_q15.c arm_negate_q31.c arm_negate_q7.c arm_not_u16.c arm_not_u32.c arm_not_u8.c arm_offset_f16.c arm_offset_f32.c arm_offset_f64.c arm_offset_q15.c arm_offset_q31.c arm_offset_q7.c arm_or_u16.c arm_or_u32.c arm_or_u8.c arm_scale_f16.c arm_scale_f32.c arm_scale_f64.c arm_scale_q15.c arm_scale_q31.c arm_scale_q7.c arm_shift_q15.c arm_shift_q31.c arm_shift_q7.c arm_sub_f16.c arm_sub_f32.c arm_sub_f64.c arm_sub_q15.c arm_sub_q31.c arm_sub_q7.c arm_xor_u16.c arm_xor_u32.c arm_xor_u8.c BasicMathFunctions.c BasicMathFunctionsF16.c
  group CMSIS/DSP/Source/BayesFunctions
    CMSIS/DSP/Source/BayesFunctions/: arm_gaussian_naive_bayes_predict_f16.c arm_gaussian_naive_bayes_predict_f32.c BayesFunctions.c BayesFunctionsF16.c
  group CMSIS/DSP/Source/CommonTables
    CMSIS/DSP/Source/CommonTables/: arm_common_tables.c arm_common_tables_f16.c arm_const_structs.c arm_const_structs_f16.c arm_mve_tables.c arm_mve_tables_f16.c CommonTables.c CommonTablesF16.c
  group CMSIS/DSP/Source/ComplexMathFunctions
    CMSIS/DSP/Source/ComplexMathFunctions/: arm_cmplx_conj_f16.c arm_cmplx_conj_f32.c arm_cmplx_conj_q15.c arm_cmplx_conj_q31.c arm_cmplx_dot_prod_f16.c arm_cmplx_dot_prod_f32.c arm_cmplx_dot_prod_q15.c arm_cmplx_dot_prod_q31.c arm_cmplx_mag_f16.c arm_cmplx_mag_f32.c arm_cmplx_mag_f64.c arm_cmplx_mag_fast_q15.c arm_cmplx_mag_q15.c arm_cmplx_mag_q31.c arm_cmplx_mag_squared_f16.c arm_cmplx_mag_squared_f32.c arm_cmplx_mag_squared_f64.c arm_cmplx_mag_squared_q15.c arm_cmplx_mag_squared_q31.c arm_cmplx_mult_cmplx_f16.c arm_cmplx_mult_cmplx_f32.c arm_cmplx_mult_cmplx_f64.c arm_cmplx_mult_cmplx_q15.c arm_cmplx_mult_cmplx_q31.c arm_cmplx_mult_real_f16.c arm_cmplx_mult_real_f32.c arm_cmplx_mult_real_q15.c arm_cmplx_mult_real_q31.c ComplexMathFunctions.c ComplexMathFunctionsF16.c
  group CMSIS/DSP/Source/ControllerFunctions
    CMSIS/DSP/Source/ControllerFunctions/: arm_pid_init_f32.c arm_pid_init_q15.c arm_pid_init_q31.c arm_pid_reset_f32.c arm_pid_reset_q15.c arm_pid_reset_q31.c arm_sin_cos_f32.c arm_sin_cos_q31.c ControllerFunctions.c
  group CMSIS/DSP/Source/DistanceFunctions
    CMSIS/DSP/Source/DistanceFunctions/: arm_boolean_distance.c arm_boolean_distance_template.h arm_braycurtis_distance_f16.c arm_braycurtis_distance_f32.c arm_canberra_distance_f16.c arm_canberra_distance_f32.c arm_chebyshev_distance_f16.c arm_chebyshev_distance_f32.c arm_chebyshev_distance_f64.c arm_cityblock_distance_f16.c arm_cityblock_distance_f32.c arm_cityblock_distance_f64.c arm_correlation_distance_f16.c arm_correlation_distance_f32.c arm_cosine_distance_f16.c arm_cosine_distance_f32.c arm_cosine_distance_f64.c arm_dice_distance.c arm_dtw_distance_f32.c arm_dtw_init_window_q7.c arm_dtw_path_f32.c arm_euclidean_distance_f16.c arm_euclidean_distance_f32.c arm_euclidean_distance_f64.c arm_hamming_distance.c arm_jaccard_distance.c arm_jensenshannon_distance_f16.c arm_jensenshannon_distance_f32.c arm_kulsinski_distance.c arm_minkowski_distance_f16.c arm_minkowski_distance_f32.c arm_rogerstanimoto_distance.c arm_russellrao_distance.c arm_sokalmichener_distance.c arm_sokalsneath_distance.c arm_yule_distance.c DistanceFunctions.c DistanceFunctionsF16.c
  group CMSIS/DSP/Source/FastMathFunctions
    CMSIS/DSP/Source/FastMathFunctions/: arm_atan2_f16.c arm_atan2_f32.c arm_atan2_q15.c arm_atan2_q31.c arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_divide_q15.c arm_divide_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c arm_vexp_f16.c arm_vexp_f32.c arm_vexp_f64.c arm_vinverse_f16.c arm_vlog_f16.c arm_vlog_f32.c arm_vlog_f64.c arm_vlog_q15.c arm_vlog_q31.c FastMathFunctions.c FastMathFunctionsF16.c
  group CMSIS/DSP/Source/FilteringFunctions
    CMSIS/DSP/Source/FilteringFunctions/: arm_biquad_cascade_df1_32x64_init_q31.c arm_biquad_cascade_df1_32x64_q31.c arm_biquad_cascade_df1_f16.c arm_biquad_cascade_df1_f32.c arm_biquad_cascade_df1_fast_q15.c arm_biquad_cascade_df1_fast_q31.c arm_biquad_cascade_df1_init_f16.c arm_biquad_cascade_df1_init_f32.c arm_biquad_cascade_df1_init_q15.c arm_biquad_cascade_df1_init_q31.c arm_biquad_cascade_df1_q15.c arm_biquad_cascade_df1_q31.c arm_biquad_cascade_df2T_f16.c arm_biquad_cascade_df2T_f32.c arm_biquad_cascade_df2T_f64.c arm_biquad_cascade_df2T_init_f16.c arm_biquad_cascade_df2T_init_f32.c arm_biquad_cascade_df2T_init_f64.c arm_biquad_cascade_stereo_df2T_f16.c arm_biquad_cascade_stereo_df2T_f32.c arm_biquad_cascade_stereo_df2T_init_f16.c arm_biquad_cascade_stereo_df2T_init_f32.c arm_conv_f32.c arm_conv_fast_opt_q15.c arm_conv_fast_q15.c arm_conv_fast_q31.c arm_conv_opt_q15.c arm_conv_opt_q7.c arm_conv_partial_f32.c arm_conv_partial_fast_opt_q15.c arm_conv_partial_fast_q15.c arm_conv_partial_fast_q31.c arm_conv_partial_opt_q15.c arm_conv_partial_opt_q7.c arm_conv_partial_q15.c arm_conv_partial_q31.c arm_conv_partial_q7.c arm_conv_q15.c arm_conv_q31.c arm_conv_q7.c arm_correlate_f16.c arm_correlate_f32.c arm_correlate_f64.c arm_correlate_fast_opt_q15.c arm_correlate_fast_q15.c arm_correlate_fast_q31.c arm_correlate_opt_q15.c arm_correlate_opt_q7.c arm_correlate_q15.c arm_correlate_q31.c arm_correlate_q7.c arm_fir_decimate_f32.c arm_fir_decimate_fast_q15.c arm_fir_decimate_fast_q31.c arm_fir_decimate_init_f32.c arm_fir_decimate_init_q15.c arm_fir_decimate_init_q31.c arm_fir_decimate_q15.c arm_fir_decimate_q31.c arm_fir_f16.c arm_fir_f32.c arm_fir_f64.c arm_fir_fast_q15.c arm_fir_fast_q31.c arm_fir_init_f16.c arm_fir_init_f32.c arm_fir_init_f64.c arm_fir_init_q15.c arm_fir_init_q31.c arm_fir_init_q7.c arm_fir_interpolate_f32.c arm_fir_interpolate_init_f32.c arm_fir_interpolate_init_q15.c arm_fir_interpolate_init_q31.c arm_fir_interpolate_q15.c arm_fir_interpolate_q31.c arm_fir_lattice_f32.c arm_fir_lattice_init_f32.c arm_fir_lattice_init_q15.c arm_fir_lattice_init_q31.c arm_fir_lattice_q15.c arm_fir_lattice_q31.c arm_fir_q15.c arm_fir_q31.c arm_fir_q7.c arm_fir_sparse_f32.c arm_fir_sparse_init_f32.c arm_fir_sparse_init_q15.c arm_fir_sparse_init_q31.c arm_fir_sparse_init_q7.c arm_fir_sparse_q15.c arm_fir_sparse_q31.c arm_fir_sparse_q7.c arm_iir_lattice_f32.c arm_iir_lattice_init_f32.c arm_iir_lattice_init_q15.c arm_iir_lattice_init_q31.c arm_iir_lattice_q15.c arm_iir_lattice_q31.c arm_levinson_durbin_f16.c arm_levinson_durbin_f32.c arm_levinson_durbin_q31.c arm_lms_f32.c arm_lms_init_f32.c arm_lms_init_q15.c arm_lms_init_q31.c arm_lms_norm_f32.c arm_lms_norm_init_f32.c arm_lms_norm_init_q15.c arm_lms_norm_init_q31.c arm_lms_norm_q15.c arm_lms_norm_q31.c arm_lms_q15.c arm_lms_q31.c FilteringFunctions.c FilteringFunctionsF16.c
  group CMSIS/DSP/Source/InterpolationFunctions
    CMSIS/DSP/Source/InterpolationFunctions/: arm_bilinear_interp_f16.c arm_bilinear_interp_f32.c arm_bilinear_interp_q15.c arm_bilinear_interp_q31.c arm_bilinear_interp_q7.c arm_linear_interp_f16.c arm_linear_interp_f32.c arm_linear_interp_q15.c arm_linear_interp_q31.c arm_linear_interp_q7.c arm_spline_interp_f32.c arm_spline_interp_init_f32.c InterpolationFunctions.c InterpolationFunctionsF16.c
  group CMSIS/DSP/Source/MatrixFunctions
    CMSIS/DSP/Source/MatrixFunctions/: arm_householder_f16.c arm_householder_f32.c arm_householder_f64.c arm_mat_add_f16.c arm_mat_add_f32.c arm_mat_add_q15.c arm_mat_add_q31.c arm_mat_cholesky_f16.c arm_mat_cholesky_f32.c arm_mat_cholesky_f64.c arm_mat_cmplx_mult_f16.c arm_mat_cmplx_mult_f32.c arm_mat_cmplx_mult_q15.c arm_mat_cmplx_mult_q31.c arm_mat_cmplx_trans_f16.c arm_mat_cmplx_trans_f32.c arm_mat_cmplx_trans_q15.c arm_mat_cmplx_trans_q31.c arm_mat_init_f16.c arm_mat_init_f32.c arm_mat_init_f64.c arm_mat_init_q15.c arm_mat_init_q31.c arm_mat_inverse_f16.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_ldlt_f32.c arm_mat_ldlt_f64.c arm_mat_mult_f16.c arm_mat_mult_f32.c arm_mat_mult_f64.c arm_mat_mult_fast_q15.c arm_mat_mult_fast_q31.c arm_mat_mult_opt_q31.c arm_mat_mult_q15.c arm_mat_mult_q31.c arm_mat_mult_q7.c arm_mat_qr_f16.c arm_mat_qr_f32.c arm_mat_qr_f64.c arm_mat_scale_f16.c arm_mat_scale_f32.c arm_mat_scale_q15.c arm_mat_scale_q31.c arm_mat_solve_lower_triangular_f16.c arm_mat_solve_lower_triangular_f32.c arm_mat_solve_lower_triangular_f64.c arm_mat_solve_upper_triangular_f16.c arm_mat_solve_upper_triangular_f32.c arm_mat_solve_upper_triangular_f64.c arm_mat_sub_f16.c arm_mat_sub_f32.c arm_mat_sub_f64.c arm_mat_sub_q15.c arm_mat_sub_q31.c arm_mat_trans_f16.c arm_mat_trans_f32.c arm_mat_trans_f64.c arm_mat_trans_q15.c arm_mat_trans_q31.c arm_mat_trans_q7.c arm_mat_vec_mult_f16.c arm_mat_vec_mult_f32.c arm_mat_vec_mult_q15.c arm_mat_vec_mult_q31.c arm_mat_vec_mult_q7.c MatrixFunctions.c MatrixFunctionsF16.c
  group CMSIS/DSP/Source/QuaternionMathFunctions
    CMSIS/DSP/Source/QuaternionMathFunctions/: arm_quaternion2rotation_f32.c arm_quaternion_conjugate_f32.c arm_quaternion_inverse_f32.c arm_quaternion_norm_f32.c arm_quaternion_normalize_f32.c arm_quaternion_product_f32.c arm_quaternion_product_single_f32.c arm_rotation2quaternion_f32.c QuaternionMathFunctions.c
  group CMSIS/DSP/Source/StatisticsFunctions
    CMSIS/DSP/Source/StatisticsFunctions/: arm_absmax_f16.c arm_absmax_f32.c arm_absmax_f64.c arm_absmax_no_idx_f16.c arm_absmax_no_idx_f32.c arm_absmax_no_idx_f64.c arm_absmax_no_idx_q15.c arm_absmax_no_idx_q31.c arm_absmax_no_idx_q7.c arm_absmax_q15.c arm_absmax_q31.c arm_absmax_q7.c arm_absmin_f16.c arm_absmin_f32.c arm_absmin_f64.c arm_absmin_no_idx_f16.c arm_absmin_no_idx_f32.c arm_absmin_no_idx_f64.c arm_absmin_no_idx_q15.c arm_absmin_no_idx_q31.c arm_absmin_no_idx_q7.c arm_absmin_q15.c arm_absmin_q31.c arm_absmin_q7.c arm_accumulate_f16.c arm_accumulate_f32.c arm_accumulate_f64.c arm_entropy_f16.c arm_entropy_f32.c arm_entropy_f64.c arm_kullback_leibler_f16.c arm_kullback_leibler_f32.c arm_kullback_leibler_f64.c arm_logsumexp_dot_prod_f16.c arm_logsumexp_dot_prod_f32.c arm_logsumexp_f16.c arm_logsumexp_f32.c arm_max_f16.c arm_max_f32.c arm_max_f64.c arm_max_no_idx_f16.c arm_max_no_idx_f32.c arm_max_no_idx_f64.c arm_max_no_idx_q15.c arm_max_no_idx_q31.c arm_max_no_idx_q7.c arm_max_q15.c arm_max_q31.c arm_max_q7.c arm_mean_f16.c arm_mean_f32.c arm_mean_f64.c arm_mean_q15.c arm_mean_q31.c arm_mean_q7.c arm_min_f16.c arm_min_f32.c arm_min_f64.c arm_min_no_idx_f16.c arm_min_no_idx_f32.c arm_min_no_idx_f64.c arm_min_no_idx_q15.c arm_min_no_idx_q31.c arm_min_no_idx_q7.c arm_min_q15.c arm_min_q31.c arm_min_q7.c arm_mse_f16.c arm_mse_f32.c arm_mse_f64.c arm_mse_q15.c arm_mse_q31.c arm_mse_q7.c arm_power_f16.c arm_power_f32.c arm_power_f64.c arm_power_q15.c arm_power_q31.c arm_power_q7.c arm_rms_f16.c arm_rms_f32.c arm_rms_q15.c arm_rms_q31.c arm_std_f16.c arm_std_f32.c arm_std_f64.c arm_std_q15.c arm_std_q31.c arm_var_f16.c arm_var_f32.c arm_var_f64.c arm_var_q15.c arm_var_q31.c StatisticsFunctions.c StatisticsFunctionsF16.c
  group CMSIS/DSP/Source/SupportFunctions
    CMSIS/DSP/Source/SupportFunctions/: arm_barycenter_f16.c arm_barycenter_f32.c arm_bitonic_sort_f32.c arm_bubble_sort_f32.c arm_copy_f16.c arm_copy_f32.c arm_copy_f64.c arm_copy_q15.c arm_copy_q31.c arm_copy_q7.c arm_f16_to_f64.c arm_f16_to_float.c arm_f16_to_q15.c arm_f64_to_f16.c arm_f64_to_float.c arm_f64_to_q15.c arm_f64_to_q31.c arm_f64_to_q7.c arm_fill_f16.c arm_fill_f32.c arm_fill_f64.c arm_fill_q15.c arm_fill_q31.c arm_fill_q7.c arm_float_to_f16.c arm_float_to_f64.c arm_float_to_q15.c arm_float_to_q31.c arm_float_to_q7.c arm_heap_sort_f32.c arm_insertion_sort_f32.c arm_merge_sort_f32.c arm_merge_sort_init_f32.c arm_q15_to_f16.c arm_q15_to_f64.c arm_q15_to_float.c arm_q15_to_q31.c arm_q15_to_q7.c arm_q31_to_f64.c arm_q31_to_float.c arm_q31_to_q15.c arm_q31_to_q7.c arm_q7_to_f64.c arm_q7_to_float.c arm_q7_to_q15.c arm_q7_to_q31.c arm_quick_sort_f32.c arm_selection_sort_f32.c arm_sort_f32.c arm_sort_init_f32.c arm_weighted_sum_f16.c arm_weighted_sum_f32.c SupportFunctions.c SupportFunctionsF16.c
  group CMSIS/DSP/Source/SVMFunctions
    CMSIS/DSP/Source/SVMFunctions/: arm_svm_linear_init_f16.c arm_svm_linear_init_f32.c arm_svm_linear_predict_f16.c arm_svm_linear_predict_f32.c arm_svm_polynomial_init_f16.c arm_svm_polynomial_init_f32.c arm_svm_polynomial_predict_f16.c arm_svm_polynomial_predict_f32.c arm_svm_rbf_init_f16.c arm_svm_rbf_init_f32.c arm_svm_rbf_predict_f16.c arm_svm_rbf_predict_f32.c arm_svm_sigmoid_init_f16.c arm_svm_sigmoid_init_f32.c arm_svm_sigmoid_predict_f16.c arm_svm_sigmoid_predict_f32.c SVMFunctions.c SVMFunctionsF16.c
  group CMSIS/DSP/Source/TransformFunctions
    CMSIS/DSP/Source/TransformFunctions/: arm_bitreversal.c arm_bitreversal2.c arm_bitreversal_f16.c arm_cfft_f16.c arm_cfft_f32.c arm_cfft_f64.c arm_cfft_init_f16.c arm_cfft_init_f32.c arm_cfft_init_f64.c arm_cfft_init_q15.c arm_cfft_init_q31.c arm_cfft_q15.c arm_cfft_q31.c arm_cfft_radix2_f16.c arm_cfft_radix2_f32.c arm_cfft_radix2_init_f16.c arm_cfft_radix2_init_f32.c arm_cfft_radix2_init_q15.c arm_cfft_radix2_init_q31.c arm_cfft_radix2_q15.c arm_cfft_radix2_q31.c arm_cfft_radix4_f16.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f16.c arm_cfft_radix4_init_f32.c arm_cfft_radix4_init_q15.c arm_cfft_radix4_init_q31.c arm_cfft_radix4_q15.c arm_cfft_radix4_q31.c arm_cfft_radix8_f16.c arm_cfft_radix8_f32.c arm_dct4_f32.c arm_dct4_init_f32.c arm_dct4_init_q15.c arm_dct4_init_q31.c arm_dct4_q15.c arm_dct4_q31.c arm_mfcc_f16.c arm_mfcc_f32.c arm_mfcc_init_f16.c arm_mfcc_init_f32.c arm_mfcc_init_q15.c arm_mfcc_init_q31.c arm_mfcc_q15.c arm_mfcc_q31.c arm_rfft_f32.c arm_rfft_fast_f16.c arm_rfft_fast_f32.c arm_rfft_fast_f64.c arm_rfft_fast_init_f16.c arm_rfft_fast_init_f32.c arm_rfft_fast_init_f64.c arm_rfft_init_f32.c arm_rfft_init_q15.c arm_rfft_init_q31.c arm_rfft_q15.c arm_rfft_q31.c TransformFunctions.c TransformFunctionsF16.c
  group CMSIS/DSP/Source/WindowFunctions
    CMSIS/DSP/Source/WindowFunctions/: arm_bartlett_f32.c arm_bartlett_f64.c arm_blackman_harris_92db_f32.c arm_blackman_harris_92db_f64.c arm_hamming_f32.c arm_hamming_f64.c arm_hanning_f32.c arm_hanning_f64.c arm_hft116d_f32.c arm_hft116d_f64.c arm_hft144d_f32.c arm_hft144d_f64.c arm_hft169d_f32.c arm_hft169d_f64.c arm_hft196d_f32.c arm_hft196d_f64.c arm_hft223d_f32.c arm_hft223d_f64.c arm_hft248d_f32.c arm_hft248d_f64.c arm_hft90d_f32.c arm_hft90d_f64.c arm_hft95_f32.c arm_hft95_f64.c arm_nuttall3_f32.c arm_nuttall3_f64.c arm_nuttall3a_f32.c arm_nuttall3a_f64.c arm_nuttall3b_f32.c arm_nuttall3b_f64.c arm_nuttall4_f32.c arm_nuttall4_f64.c arm_nuttall4a_f32.c arm_nuttall4a_f64.c arm_nuttall4b_f32.c arm_nuttall4b_f64.c arm_nuttall4c_f32.c arm_nuttall4c_f64.c arm_welch_f32.c arm_welch_f64.c WindowFunctions.c
  group codec
    codec/: fsl_codec_common.c fsl_codec_common.h fsl_codec_i2c.c fsl_codec_i2c.h fsl_wm8960.c fsl_wm8960.h
  group codec/port
    codec/port/: fsl_codec_adapter.h
  group codec/port/wm8960
    codec/port/wm8960/: fsl_codec_wm8960_adapter.c fsl_codec_wm8960_adapter.h
  group component/gpio
    component/gpio/: fsl_adapter_gpio.h fsl_adapter_igpio.c
  group component/i2c
    component/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group component/lists
    component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/osa
    component/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
  group component/uart
    component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    device/: fsl_device_registers.h MIMXRT1021.h MIMXRT1021_features.h system_MIMXRT1021.c system_MIMXRT1021.h
  group drivers
    drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_usdhc.c fsl_usdhc.h
  group fatfs/source
    fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group fatfs/source/fsl_sd_disk
    fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group sdmmc/host
    sdmmc/host/: ChangeLogKSDK.txt fsl_sdmmc_host.c fsl_sdmmc_host.h
  group sdmmc/inc
    sdmmc/inc/: fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_spec.h
  group sdmmc/osa
    sdmmc/osa/: fsl_sdmmc_osa.c fsl_sdmmc_osa.h
  group sdmmc/sd
    sdmmc/sd/: ChangeLogKSDK.txt
  group sdmmc/src
    sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
  group source
    source/: ffconf.h playbackSineWave.c recordPlayback.c recordtoSdcard.c sai.c sai.h
  group startup
    startup/: startup_MIMXRT1021.S
  group utilities
    utilities/: fsl_assert.c fsl_assert.h fsl_debug_console.c fsl_debug_console.h fsl_str.c fsl_str.h
  group xip
    xip/: evkmimxrt1020_flexspi_nor_config.c evkmimxrt1020_flexspi_nor_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group machine_learning
    ./packs/tensorflow-lite/2.4.0/tensorflow/core/public/: version.h
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/: portable_type_to_tflitetype.h
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/c/: builtin_op_data.h common.c common.h
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/core/api/: error_reporter.cc error_reporter.h flatbuffer_conversions.cc flatbuffer_conversions.h op_resolver.cc op_resolver.h profiler.h tensor_utils.cc tensor_utils.h
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels/: kernel_util.h op_macros.h padding.h kernel_util_.cc
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels/internal/: compatibility.h cppmath.h max.h min.h portable_tensor.h quantization_util.cc quantization_util.h strided_slice_logic.h tensor_ctypes.h types.h
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels/internal/optimized/: neon_check.h
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels/internal/reference/: add.h arg_min_max.h binary_function.h ceil.h comparisons.h concatenation.h conv.h depthwiseconv_float.h depthwiseconv_uint8.h dequantize.h floor.h fully_connected.h hard_swish.h l2normalization.h logistic.h maximum_minimum.h mul.h neg.h pad.h pooling.h prelu.h process_broadcast_shapes.h quantize.h reduce.h requantize.h resize_nearest_neighbor.h round.h softmax.h strided_slice.h sub.h tanh.h
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels/internal/reference/integer_ops/: depthwise_conv.h
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/micro/: all_ops_resolver.cc all_ops_resolver.h debug_log.cc debug_log.h memory_helpers.cc memory_helpers.h micro_allocator.cc micro_allocator.h micro_error_reporter.cc micro_error_reporter.h micro_interpreter.cc micro_interpreter.h micro_mutable_op_resolver.h micro_op_resolver.h micro_optional_debug_tools.cc micro_optional_debug_tools.h micro_profiler.cc micro_profiler.h micro_string.cc micro_string.h micro_time.cc micro_time.h micro_utils.cc micro_utils.h recording_micro_allocator.cc recording_micro_allocator.h recording_micro_interpreter.h recording_simple_memory_allocator.cc recording_simple_memory_allocator.h simple_memory_allocator.cc simple_memory_allocator.h test_helpers.cc test_helpers.h
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/micro/benchmarks/: keyword_scrambled_model_data.cc keyword_scrambled_model_data.h
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/micro/kernels/: activation_utils.h activations.cc add.cc arg_min_max.cc ceil.cc circular_buffer.cc comparisons.cc concatenation.cc conv.cc depthwise_conv.cc dequantize.cc elementwise.cc ethosu.cc floor.cc fully_connected.cc hard_swish.cc kernel_runner.cc kernel_runner.h l2norm.cc logical.cc logistic.cc maximum_minimum.cc micro_ops.h mul.cc neg.cc pack.cc pad.cc pooling.cc prelu.cc quantize.cc reduce.cc reshape.cc resize_nearest_neighbor.cc round.cc softmax.cc split.cc strided_slice.cc sub.cc svdf.cc tanh.cc unpack.cc kernel_util.cc
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.cc greedy_memory_planner.h linear_memory_planner.cc linear_memory_planner.h memory_planner.h
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/micro/testing/: micro_test.h test_conv_model.cc test_conv_model.h test_utils.cc test_utils.h
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/schema/: schema_generated.h
  group src
    ./src/: audio_provider.cc audio_provider.h audio_provider_default.cc audio_provider_test.cc command_responder.cc command_responder.h feature_provider.cc feature_provider.h feature_provider_test.cc main.cc main_functions.cc main_functions.cc.bak main_functions.h main_functions_test.cc output_handler.cc output_handler.h Platform.c recognize_commands.cc recognize_commands.h todo.txt
    ./src/i.MXRT/: main.c main.h retarget_stdio.c
    ./src/micro_features/: micro_features_generator.cc micro_features_generator.h micro_model_settings.cc micro_model_settings.h model.cc model.cc.bak model.h no_micro_features_data.cc no_micro_features_data.h yes_micro_features_data.cc yes_micro_features_data.h
    ./src/micro_frontend/lib/: bits.h BUILD fft.cc fft.h fft_io.c fft_io.h fft_test.cc fft_util.cc fft_util.h filterbank.c filterbank.h filterbank_io.c filterbank_io.h filterbank_test.cc filterbank_util.c filterbank_util.h frontend.c frontend.h frontend_io.c frontend_io.h frontend_main.c frontend_memmap_generator.c frontend_memmap_main.c frontend_test.cc frontend_util.c frontend_util.h log_lut.c log_lut.h log_scale.c log_scale.h log_scale_io.c log_scale_io.h log_scale_test.cc log_scale_util.c log_scale_util.h noise_reduction.c noise_reduction.h noise_reduction_io.c noise_reduction_io.h noise_reduction_test.cc noise_reduction_util.c noise_reduction_util.h pcan_gain_control.c pcan_gain_control.h pcan_gain_control_test.cc pcan_gain_control_util.c pcan_gain_control_util.h README.md window.c window.h window_io.c window_io.h window_test.cc window_util.c window_util.h malloc.c malloc.h
    ./src/test/: no_30ms_sample_data.cc no_30ms_sample_data.h no_1000ms_sample_data.cc no_1000ms_sample_data.h yes_30ms_sample_data.cc yes_30ms_sample_data.h yes_1000ms_sample_data.cc yes_1000ms_sample_data.h
  group kissfft
    ./packs/kissfft/1.3.1/src/: kiss_fft.c kiss_fft.h kiss_fft_log.h kissfft.hh kissfft_i32.hh
    ./packs/kissfft/1.3.1/src/tools/: fftutil.c kfc.c kfc.h kiss_fastfir.c kiss_fftnd.c kiss_fftnd.h kiss_fftndr.c kiss_fftndr.h kiss_fftr.c kiss_fftr.h psdpng.c
target sai flexspi_nor_release (ARM-ADS)
  device: MIMXRT1021DAG5A NXP
  pack: NXP.MIMXRT1021_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: sai.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, ARM_MATH_CM7, ARM_MATH_CM4, CPU_MIMXRT1021DAG5A, PRINTF_FLOAT_ENABLE=1, MCUXPRESSO_SDK, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_WM8960_ENABLE, DISABLEFLOAT16, SD_ENABLED
  c misc: -fno-common -fdata-sections -fno-builtin -mthumb
  c include: board;source;CMSIS;CMSIS/DSP/Include;CMSIS/DSP/PrivateInclude;CMSIS/DSP/Source/DistanceFunctions;codec;codec/port;codec/port/wm8960;component/gpio;component/i2c;component/lists;component/osa;component/uart;device;drivers;evkmimxrt1020/demo_apps/sai;fatfs/source;fatfs/source/fsl_sd_disk;sdmmc/host;sdmmc/inc;sdmmc/osa;sdmmc/template/usdhc;utilities;xip
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1021/arm/MIMXRT1021xxxxx_flexspi_nor.scf
  link misc: as above
